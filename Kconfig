## Kconfig
```kconfig
config RTL8821CU
	tristate "Realtek 8821C USB WiFi"
	depends on USB
	help
	  Help message for RTL8821CU
```
